# Keil uVision project aaa.uvprojx, settings and files
target aaa (5060750::V5.06 update 6 (build 750)::.\ARMCC)
  device: STM32F103C8 STMicroelectronics
  pack: Keil.STM32F1xx_DFP.2.4.1
  cpu: IRAM(0x20000000-0x20004FFF) IROM(0x8000000-0x800FFFF) CLOCK(8000000) CPUTYPE("Cortex-M3") TZ
  output: aaa +hex
  c flags: Optim=4 OneElfS=1 uC99=1 v6Lang=5 v6LangP=3 wLevel=2
  c define: USE_HAL_DRIVER,STM32F103xB
  c include: ../Core/Inc;../Drivers/STM32F1xx_HAL_Driver/Inc;../Drivers/STM32F1xx_HAL_Driver/Inc/Legacy;../Drivers/CMSIS/Device/ST/STM32F1xx/Include;../Drivers/CMSIS/Include;../Common;../BSP;../Control;../Strategy;..\Debug;../Application
  memory RVCT4: ROM 0x8000000 size 0x10000
  memory RVCT9: RAM 0x20000000 size 0x5000
  group Application/MDK-ARM
    ./: startup_stm32f103xb.s
  group Application/User/Core
    ../Core/Src/: main.c gpio.c dma.c i2c.c tim.c usart.c stm32f1xx_it.c stm32f1xx_hal_msp.c
  group Drivers/STM32F1xx_HAL_Driver
    ../Drivers/STM32F1xx_HAL_Driver/Src/: stm32f1xx_hal_gpio_ex.c stm32f1xx_hal_i2c.c stm32f1xx_hal.c stm32f1xx_hal_rcc.c stm32f1xx_hal_rcc_ex.c stm32f1xx_hal_gpio.c stm32f1xx_hal_dma.c stm32f1xx_hal_cortex.c stm32f1xx_hal_pwr.c stm32f1xx_hal_flash.c stm32f1xx_hal_flash_ex.c stm32f1xx_hal_exti.c stm32f1xx_hal_tim.c stm32f1xx_hal_tim_ex.c stm32f1xx_hal_uart.c
  group Drivers/CMSIS
    ../Core/Src/: system_stm32f1xx.c
  group Common
    ../Common/: car_config.h car_types.h runtime_config.c runtime_config.h
  group BSP
    ../BSP/: bsp_encoder.c bsp_encoder.h bsp_imu.c bsp_imu.h bsp_line.c bsp_line.h bsp_motor.c bsp_motor.h bsp_oled.c bsp_oled.h bsp_hc05.c bsp_hc05.h
  group Control
    ../Control/: line_pid.c line_pid.h speed_pid.c speed_pid.h remote_control.c remote_control.h
  group Strategy
    ../Strategy/: track_map.c track_map.h track_strategy.c track_strategy.h
  group Debug/PIDScope
    ../Debug/PIDScope/: pid_debug.c pid_debug.h pid_scope_adapter.c pid_scope_adapter.h
  group Application
    ../Application/: app_car.c app_car.h
software components: CMSIS:CORE 5.6.0
